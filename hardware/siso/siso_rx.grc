options:
  parameters:
    author: abhilash
    generate_options: qt_gui
    id: spatialdiver_sdr_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: 'Phase: Bandwidth'
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW'
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_rect_0
    modulus: '4'
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: int(arity)
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: '2'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from gnuradio import grc

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='datatypeconversion',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.snr=0
              #print(222)
          def handle_msg(self,msg):
              self.snr=pmt.to_float(msg)
              #print(22)
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print(2)
              output_items[0][:] = self.snr 
              return len(output_items[0])
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from gnuradio import grc

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='datatypeconversion',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.snr=0
              #print(222)
          def handle_msg(self,msg):
              self.snr=pmt.to_float(msg)
              #print(22)
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print(2)
              output_items[0][:] = self.snr 
              return len(output_items[0])
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    bb_gain0: '30'
    bw0: 5e6
    freq0: 600e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    max: '30'
    min: '0'
    name: reciver snr
    type: float
    unit1: dB
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    max: '30'
    min: '0'
    name: osmosource output
    type: float
    unit1: dB
  states: {}

connections:
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, epy_block_1_0, snr]
- [digital_probe_mpsk_snr_est_c_0_0, snr, epy_block_1_0_0, snr]
- [digital_symbol_sync_xx_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0, '0']
- [epy_block_1_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_1_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [osmosdr_source_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [osmosdr_source_0_0, '0', digital_probe_mpsk_snr_est_c_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
